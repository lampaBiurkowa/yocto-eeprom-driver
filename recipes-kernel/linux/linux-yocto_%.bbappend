FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-enable-i2c.patch"
